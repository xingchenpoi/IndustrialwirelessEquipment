# IAR project IndustrialwirelessEquipment.ewp, settings and files
configuration IndustrialwirelessEquipment (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F103xB
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F1xx/Include; ../Drivers/CMSIS/Include; ..\BSP\ins
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: IndustrialwirelessEquipment.hex
  ILINK.IlinkOutputFile: IndustrialwirelessEquipment.out
  ILINK.IlinkIcfFile: stm32f103xb_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f103xb.s
  group Application/User
    ../Src/: APP_DebugProtocol.c APP_Di.c APP_Do.c APP_Led.c APP_LORA.c APP_Modbus.c APP_rs485.c APP_Scheduler.c APP_Task.c APP_Timer.c delay.c main.c stm32f1xx_hal_msp.c stm32f1xx_it.c sys.c sysram.c
    ../Inc/: APP_DebugProtocol.h APP_Di.h APP_Do.h APP_Led.h APP_LORA.h APP_Modbus.h APP_rs485.h APP_Scheduler.h APP_Task.h APP_Timer.h appdef.h delay.h includes.h main.h stm32f1xx_hal_conf.h stm32f1xx_it.h sys.h sysram.h typedef.h
  group BSP/ins
    ../BSP/ins/: bsp.h bsp_Di.h bsp_dma.h bsp_Do.h bsp_led.h bsp_mcp3208.h bsp_rs485.h bsp_spi.h bsp_stmFlash.h bsp_switch.h bsp_tim.h bsp_usart.h bsp_wdg.h
  group BSP/src
    ../BSP/src/: bsp.c bsp_Di.c bsp_dma.c bsp_Do.c bsp_led.c bsp_mcp3208.c bsp_rs485.c bsp_spi.c bsp_stmFlash.c bsp_switch.c bsp_tim.c bsp_usart.c bsp_wdg.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
